# Repository sparkfun/Logic_Level_Bidirectional (continued)

## EAGLE design Production Files/Logic_Level_Bidirectional-Panel-v01.brd

Board: 2 copper layers, 123.4 x 118.9 mm, 1011 parts (224 on the bottom side), 616 nets.

Parts:
E$1: FIDUCIAL-1.5X3
E$4, E$5: FIDUCIAL-1X2
JP1, JP2, JP5, JP6, JP9, JP10, JP13, JP14, JP17, JP18, JP21, JP22, JP25, JP26, JP29, JP30, JP33, JP34, JP37, JP38, JP41, JP42, JP45, JP46, JP49, JP50, JP53, JP54, JP57, JP58, JP61, JP62, JP65, JP66, JP69, JP70, JP73, JP74, JP77, JP78, JP81, JP82, JP85, JP86, JP89, JP90, JP93, JP94, JP97, JP98, JP101, JP102, JP105, JP106, JP109, JP110, JP113, JP114, JP117, JP118, JP121, JP122, JP125, JP126, JP129, JP130, JP133, JP134, JP137, JP138, JP141, JP142, JP145, JP146, JP149, JP150, JP153, JP154, JP157, JP158, JP161, JP162, JP165, JP166, JP169, JP170, JP173, JP174, JP177, JP178, JP181, JP182, JP185, JP186, JP189, JP190, JP193, JP194, JP197, JP198, JP201, JP202, JP205, JP206, JP209, JP210, JP213, JP214, JP217, JP218, JP221, JP222: 1X06
JP3, JP4, JP7, JP8, JP11, JP12, JP15, JP16, JP19, JP20, JP23, JP24, JP27, JP28, JP31, JP32, JP35, JP36, JP39, JP40, JP43, JP44, JP47, JP48, JP51, JP52, JP55, JP56, JP59, JP60, JP63, JP64, JP67, JP68, JP71, JP72, JP75, JP76, JP79, JP80, JP83, JP84, JP87, JP88, JP91, JP92, JP95, JP96, JP99, JP100, JP103, JP104, JP107, JP108, JP111, JP112, JP115, JP116, JP119, JP120, JP123, JP124, JP127, JP128, JP131, JP132, JP135, JP136, JP139, JP140, JP143, JP144, JP147, JP148, JP151, JP152, JP155, JP156, JP159, JP160, JP163, JP164, JP167, JP168, JP171, JP172, JP175, JP176, JP179, JP180, JP183, JP184, JP187, JP188, JP191, JP192, JP195, JP196, JP199, JP200, JP203, JP204, JP207, JP208, JP211, JP212, JP215, JP216, JP219, JP220, JP223, JP224: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
LOGO1, LOGO3, LOGO5, LOGO7, LOGO9, LOGO11, LOGO13, LOGO15, LOGO17, LOGO19, LOGO21, LOGO23, LOGO25, LOGO27, LOGO29, LOGO31, LOGO33, LOGO35, LOGO37, LOGO39, LOGO41, LOGO43, LOGO45, LOGO47, LOGO49, LOGO51, LOGO53, LOGO55, LOGO57, LOGO59, LOGO61, LOGO63, LOGO65, LOGO67, LOGO69, LOGO71, LOGO73, LOGO75, LOGO77, LOGO79, LOGO81, LOGO83, LOGO85, LOGO87, LOGO89, LOGO91, LOGO93, LOGO95, LOGO97, LOGO99, LOGO101, LOGO103, LOGO105, LOGO107, LOGO109, LOGO111: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
LOGO2, LOGO4, LOGO6, LOGO8, LOGO10, LOGO12, LOGO14, LOGO16, LOGO18, LOGO20, LOGO22, LOGO24, LOGO26, LOGO28, LOGO30, LOGO32, LOGO34, LOGO36, LOGO38, LOGO40, LOGO42, LOGO44, LOGO46, LOGO48, LOGO50, LOGO52, LOGO54, LOGO56, LOGO58, LOGO60, LOGO62, LOGO64, LOGO66, LOGO68, LOGO70, LOGO72, LOGO74, LOGO76, LOGO78, LOGO80, LOGO82, LOGO84, LOGO86, LOGO88, LOGO90, LOGO92, LOGO94, LOGO96, LOGO98, LOGO100, LOGO102, LOGO104, LOGO106, LOGO108, LOGO110, LOGO112: OSHW-LOGOS; OSHW-LOGO-S
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32, Q33, Q34, Q35, Q36, Q37, Q38, Q39, Q40, Q41, Q42, Q43, Q44, Q45, Q46, Q47, Q48, Q49, Q50, Q51, Q52, Q53, Q54, Q55, Q56, Q57, Q58, Q59, Q60, Q61, Q62, Q63, Q64, Q65, Q66, Q67, Q68, Q69, Q70, Q71, Q72, Q73, Q74, Q75, Q76, Q77, Q78, Q79, Q80, Q81, Q82, Q83, Q84, Q85, Q86, Q87, Q88, Q89, Q90, Q91, Q92, Q93, Q94, Q95, Q96, Q97, Q98, Q99, Q100, Q101, Q102, Q103, Q104, Q105, Q106, Q107, Q108, Q109, Q110, Q111, Q112, Q113, Q114, Q115, Q116, Q117, Q118, Q119, Q120, Q121, Q122, Q123, Q124, Q125, Q126, Q127, Q128, Q129, Q130, Q131, Q132, Q133, Q134, Q135, Q136, Q137, Q138, Q139, Q140, Q141, Q142, Q143, Q144, Q145, Q146, Q147, Q148, Q149, Q150, Q151, Q152, Q153, Q154, Q155, Q156, Q157, Q158, Q159, Q160, Q161, Q162, Q163, Q164, Q165, Q166, Q167, Q168, Q169, Q170, Q171, Q172, Q173, Q174, Q175, Q176, Q177, Q178, Q179, Q180, Q181, Q182, Q183, Q184, Q185, Q186, Q187, Q188, Q189, Q190, Q191, Q192, Q193, Q194, Q195, Q196, Q197, Q198, Q199, Q200, Q201, Q202, Q203, Q204, Q205, Q206, Q207, Q208, Q209, Q210, Q211, Q212, Q213, Q214, Q215, Q216, Q217, Q218, Q219, Q220, Q221, Q222, Q223, Q224: BSS138; SOT23-3
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R124, R125, R126, R127, R128, R129, R130, R131, R132, R133, R134, R135, R136, R137, R138, R139, R140, R141, R142, R143, R144, R145, R146, R147, R148, R149, R150, R151, R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R162, R163, R164, R165, R166, R167, R168, R169, R170, R171, R172, R173, R174, R175, R176, R177, R178, R179, R180, R181, R182, R183, R184, R185, R186, R187, R188, R189, R190, R191, R192, R193, R194, R195, R196, R197, R198, R199, R200, R201, R202, R203, R204, R205, R206, R207, R208, R209, R210, R211, R212, R213, R214, R215, R216, R217, R218, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231, R232, R233, R234, R235, R236, R237, R238, R239, R240, R241, R242, R243, R244, R245, R246, R247, R248, R249, R250, R251, R252, R253, R254, R255, R256, R257, R258, R259, R260, R261, R262, R263, R264, R265, R266, R267, R268, R269, R270, R271, R272, R273, R274, R275, R276, R277, R278, R279, R280, R281, R282, R283, R284, R285, R286, R287, R288, R289, R290, R291, R292, R293, R294, R295, R296, R297, R298, R299, R300, R301, R302, R303, R304, R305, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R316, R317, R318, R319, R320, R321, R322, R323, R324, R325, R326, R327, R328, R329, R330, R331, R332, R333, R334, R335, R336, R337, R338, R339, R340, R341, R342, R343, R344, R345, R346, R347, R348, R349, R350, R351, R352, R353, R354, R355, R356, R357, R358, R359, R360, R361, R362, R363, R364, R365, R366, R367, R368, R369, R370, R371, R372, R373, R374, R375, R376, R377, R378, R379, R380, R381, R382, R383, R384, R385, R386, R387, R388, R389, R390, R391, R392, R393, R394, R395, R396, R397, R398, R399, R400, R401, R402, R403, R404, R405, R406, R407, R408, R409, R410, R411, R412, R413, R414, R415, R416, R417, R418, R419, R420, R421, R422, R423, R424, R425, R426, R427, R428, R429, R430, R431, R432, R433, R434, R435, R436, R437, R438, R439, R440, R441, R442, R443, R444, R445, R446, R447, R448: 10K; 0603-RES

Connections:
GND: JP1.3, JP2.4
GND1: JP5.3, JP6.4
GND2: JP9.3, JP10.4
GND3: JP13.3, JP14.4
GND4: JP17.3, JP18.4
GND5: JP21.3, JP22.4
GND6: JP25.3, JP26.4
GND7: JP29.3, JP30.4
GND8: JP33.3, JP34.4
GND9: JP37.3, JP38.4
GND10: JP41.3, JP42.4
GND11: JP45.3, JP46.4
GND12: JP49.3, JP50.4
GND13: JP53.3, JP54.4
GND14: JP57.3, JP58.4
GND15: JP61.3, JP62.4
GND16: JP65.3, JP66.4
GND17: JP69.3, JP70.4
GND18: JP73.3, JP74.4
GND19: JP77.3, JP78.4
GND20: JP81.3, JP82.4
GND21: JP85.3, JP86.4
GND22: JP89.3, JP90.4
GND23: JP93.3, JP94.4
GND24: JP97.3, JP98.4
GND25: JP101.3, JP102.4
GND26: JP105.3, JP106.4
GND27: JP109.3, JP110.4
GND28: JP113.3, JP114.4
GND29: JP117.3, JP118.4
GND30: JP121.3, JP122.4
GND31: JP125.3, JP126.4
GND32: JP129.3, JP130.4
GND33: JP133.3, JP134.4
GND34: JP137.3, JP138.4
GND35: JP141.3, JP142.4
GND36: JP145.3, JP146.4
GND37: JP149.3, JP150.4
GND38: JP153.3, JP154.4
GND39: JP157.3, JP158.4
GND40: JP161.3, JP162.4
GND41: JP165.3, JP166.4
GND42: JP169.3, JP170.4
GND43: JP173.3, JP174.4
GND44: JP177.3, JP178.4
GND45: JP181.3, JP182.4
GND46: JP185.3, JP186.4
GND47: JP189.3, JP190.4
GND48: JP193.3, JP194.4
GND49: JP197.3, JP198.4
GND50: JP201.3, JP202.4
GND51: JP205.3, JP206.4
GND52: JP209.3, JP210.4
GND53: JP213.3, JP214.4
GND54: JP217.3, JP218.4
GND55: JP221.3, JP222.4
HV: JP2.3, R4.1, R5.1, R7.1, R10.1
HV1: JP2.1, Q1.3, R4.2
HV2: JP2.2, Q3.3, R10.2
HV3: JP2.5, Q4.3, R5.2
HV4: JP2.6, Q2.3, R7.2
HV5: JP6.1, Q6.3, R12.2
HV6: JP6.2, Q7.3, R14.2
HV7: JP6.3, R9.1, R12.1, R14.1, R16.1
HV8: JP6.5, Q8.3, R16.2
HV9: JP6.6, Q5.3, R9.2
HV10: JP10.1, Q10.3, R20.2
HV11: JP10.2, Q11.3, R22.2
HV12: JP10.3, R18.1, R20.1, R22.1, R24.1
HV13: JP10.5, Q12.3, R24.2
HV14: JP10.6, Q9.3, R18.2
HV15: JP14.1, Q14.3, R28.2
HV16: JP14.2, Q15.3, R30.2
HV17: JP14.3, R26.1, R28.1, R30.1, R32.1
HV18: JP14.5, Q16.3, R32.2
HV19: JP14.6, Q13.3, R26.2
HV20: JP18.1, Q18.3, R36.2
HV21: JP18.2, Q19.3, R38.2
HV22: JP18.3, R34.1, R36.1, R38.1, R40.1
HV23: JP18.5, Q20.3, R40.2
HV24: JP18.6, Q17.3, R34.2
HV25: JP22.1, Q22.3, R44.2
HV26: JP22.2, Q23.3, R46.2
HV27: JP22.3, R42.1, R44.1, R46.1, R48.1
HV28: JP22.5, Q24.3, R48.2
HV29: JP22.6, Q21.3, R42.2
HV30: JP26.1, Q26.3, R52.2
HV31: JP26.2, Q27.3, R54.2
HV32: JP26.3, R50.1, R52.1, R54.1, R56.1
HV33: JP26.5, Q28.3, R56.2
HV34: JP26.6, Q25.3, R50.2
HV35: JP30.1, Q30.3, R60.2
HV36: JP30.2, Q31.3, R62.2
HV37: JP30.3, R58.1, R60.1, R62.1, R64.1
HV38: JP30.5, Q32.3, R64.2
HV39: JP30.6, Q29.3, R58.2
HV40: JP34.1, Q34.3, R68.2
HV41: JP34.2, Q35.3, R70.2
HV42: JP34.3, R66.1, R68.1, R70.1, R72.1
HV43: JP34.5, Q36.3, R72.2
HV44: JP34.6, Q33.3, R66.2
HV45: JP38.1, Q38.3, R76.2
HV46: JP38.2, Q39.3, R78.2
HV47: JP38.3, R74.1, R76.1, R78.1, R80.1
HV48: JP38.5, Q40.3, R80.2
HV49: JP38.6, Q37.3, R74.2
HV50: JP42.1, Q42.3, R84.2
HV51: JP42.2, Q43.3, R86.2
HV52: JP42.3, R82.1, R84.1, R86.1, R88.1
HV53: JP42.5, Q44.3, R88.2
HV54: JP42.6, Q41.3, R82.2
HV55: JP46.1, Q46.3, R92.2
HV56: JP46.2, Q47.3, R94.2
HV57: JP46.3, R90.1, R92.1, R94.1, R96.1
HV58: JP46.5, Q48.3, R96.2
HV59: JP46.6, Q45.3, R90.2
HV60: JP50.1, Q50.3, R100.2
HV61: JP50.2, Q51.3, R102.2
HV62: JP50.3, R98.1, R100.1, R102.1, R104.1
HV63: JP50.5, Q52.3, R104.2
HV64: JP50.6, Q49.3, R98.2
HV65: JP54.1, Q54.3, R108.2
HV66: JP54.2, Q55.3, R110.2
HV67: JP54.3, R106.1, R108.1, R110.1, R112.1
HV68: JP54.5, Q56.3, R112.2
HV69: JP54.6, Q53.3, R106.2
HV70: JP58.1, Q58.3, R116.2
HV71: JP58.2, Q59.3, R118.2
HV72: JP58.3, R114.1, R116.1, R118.1, R120.1
HV73: JP58.5, Q60.3, R120.2
HV74: JP58.6, Q57.3, R114.2
HV75: JP62.1, Q62.3, R124.2
HV76: JP62.2, Q63.3, R126.2
HV77: JP62.3, R122.1, R124.1, R126.1, R128.1
HV78: JP62.5, Q64.3, R128.2
HV79: JP62.6, Q61.3, R122.2
HV80: JP66.1, Q66.3, R132.2
HV81: JP66.2, Q67.3, R134.2
HV82: JP66.3, R130.1, R132.1, R134.1, R136.1
HV83: JP66.5, Q68.3, R136.2
HV84: JP66.6, Q65.3, R130.2
HV85: JP70.1, Q70.3, R140.2
HV86: JP70.2, Q71.3, R142.2
HV87: JP70.3, R138.1, R140.1, R142.1, R144.1
HV88: JP70.5, Q72.3, R144.2
HV89: JP70.6, Q69.3, R138.2
HV90: JP74.1, Q74.3, R148.2
HV91: JP74.2, Q75.3, R150.2
HV92: JP74.3, R146.1, R148.1, R150.1, R152.1
HV93: JP74.5, Q76.3, R152.2
HV94: JP74.6, Q73.3, R146.2
HV95: JP78.1, Q78.3, R156.2
HV96: JP78.2, Q79.3, R158.2
HV97: JP78.3, R154.1, R156.1, R158.1, R160.1
HV98: JP78.5, Q80.3, R160.2
HV99: JP78.6, Q77.3, R154.2
HV100: JP82.1, Q82.3, R164.2
HV101: JP82.2, Q83.3, R166.2
HV102: JP82.3, R162.1, R164.1, R166.1, R168.1
HV103: JP82.5, Q84.3, R168.2
HV104: JP82.6, Q81.3, R162.2
HV105: JP86.1, Q86.3, R172.2
HV106: JP86.2, Q87.3, R174.2
HV107: JP86.3, R170.1, R172.1, R174.1, R176.1
HV108: JP86.5, Q88.3, R176.2
HV109: JP86.6, Q85.3, R170.2
HV110: JP90.1, Q90.3, R180.2
HV111: JP90.2, Q91.3, R182.2
HV112: JP90.3, R178.1, R180.1, R182.1, R184.1
HV113: JP90.5, Q92.3, R184.2
HV114: JP90.6, Q89.3, R178.2
HV115: JP94.1, Q94.3, R188.2
HV116: JP94.2, Q95.3, R190.2
HV117: JP94.3, R186.1, R188.1, R190.1, R192.1
HV118: JP94.5, Q96.3, R192.2
HV119: JP94.6, Q93.3, R186.2
HV120: JP98.1, Q98.3, R196.2
HV121: JP98.2, Q99.3, R198.2
HV122: JP98.3, R194.1, R196.1, R198.1, R200.1
HV123: JP98.5, Q100.3, R200.2
HV124: JP98.6, Q97.3, R194.2
HV125: JP102.1, Q102.3, R204.2
HV126: JP102.2, Q103.3, R206.2
HV127: JP102.3, R202.1, R204.1, R206.1, R208.1
HV128: JP102.5, Q104.3, R208.2
HV129: JP102.6, Q101.3, R202.2
HV130: JP106.1, Q106.3, R212.2
HV131: JP106.2, Q107.3, R214.2
HV132: JP106.3, R210.1, R212.1, R214.1, R216.1
HV133: JP106.5, Q108.3, R216.2
HV134: JP106.6, Q105.3, R210.2
HV135: JP110.1, Q110.3, R220.2
HV136: JP110.2, Q111.3, R222.2
HV137: JP110.3, R218.1, R220.1, R222.1, R224.1
HV138: JP110.5, Q112.3, R224.2
HV139: JP110.6, Q109.3, R218.2
HV140: JP114.1, Q114.3, R228.2
HV141: JP114.2, Q115.3, R230.2
HV142: JP114.3, R226.1, R228.1, R230.1, R232.1
HV143: JP114.5, Q116.3, R232.2
HV144: JP114.6, Q113.3, R226.2
HV145: JP118.1, Q118.3, R236.2
HV146: JP118.2, Q119.3, R238.2
HV147: JP118.3, R234.1, R236.1, R238.1, R240.1
HV148: JP118.5, Q120.3, R240.2
HV149: JP118.6, Q117.3, R234.2
HV150: JP122.1, Q122.3, R244.2
HV151: JP122.2, Q123.3, R246.2
HV152: JP122.3, R242.1, R244.1, R246.1, R248.1
HV153: JP122.5, Q124.3, R248.2
HV154: JP122.6, Q121.3, R242.2
HV155: JP126.1, Q126.3, R252.2
HV156: JP126.2, Q127.3, R254.2
HV157: JP126.3, R250.1, R252.1, R254.1, R256.1
HV158: JP126.5, Q128.3, R256.2
HV159: JP126.6, Q125.3, R250.2
HV160: JP130.1, Q130.3, R260.2
HV161: JP130.2, Q131.3, R262.2
HV162: JP130.3, R258.1, R260.1, R262.1, R264.1
HV163: JP130.5, Q132.3, R264.2
HV164: JP130.6, Q129.3, R258.2
HV165: JP134.1, Q134.3, R268.2
HV166: JP134.2, Q135.3, R270.2
HV167: JP134.3, R266.1, R268.1, R270.1, R272.1
HV168: JP134.5, Q136.3, R272.2
HV169: JP134.6, Q133.3, R266.2
HV170: JP138.1, Q138.3, R276.2
HV171: JP138.2, Q139.3, R278.2
HV172: JP138.3, R274.1, R276.1, R278.1, R280.1
HV173: JP138.5, Q140.3, R280.2
HV174: JP138.6, Q137.3, R274.2
HV175: JP142.1, Q142.3, R284.2
HV176: JP142.2, Q143.3, R286.2
HV177: JP142.3, R282.1, R284.1, R286.1, R288.1
HV178: JP142.5, Q144.3, R288.2
HV179: JP142.6, Q141.3, R282.2
HV180: JP146.1, Q146.3, R292.2
HV181: JP146.2, Q147.3, R294.2
HV182: JP146.3, R290.1, R292.1, R294.1, R296.1
HV183: JP146.5, Q148.3, R296.2
HV184: JP146.6, Q145.3, R290.2
HV185: JP150.1, Q150.3, R300.2
HV186: JP150.2, Q151.3, R302.2
HV187: JP150.3, R298.1, R300.1, R302.1, R304.1
HV188: JP150.5, Q152.3, R304.2
HV189: JP150.6, Q149.3, R298.2
HV190: JP154.1, Q154.3, R308.2
HV191: JP154.2, Q155.3, R310.2
HV192: JP154.3, R306.1, R308.1, R310.1, R312.1
HV193: JP154.5, Q156.3, R312.2
HV194: JP154.6, Q153.3, R306.2
HV195: JP158.1, Q158.3, R316.2
HV196: JP158.2, Q159.3, R318.2
HV197: JP158.3, R314.1, R316.1, R318.1, R320.1
HV198: JP158.5, Q160.3, R320.2
HV199: JP158.6, Q157.3, R314.2
HV200: JP162.1, Q162.3, R324.2
HV201: JP162.2, Q163.3, R326.2
HV202: JP162.3, R322.1, R324.1, R326.1, R328.1
HV203: JP162.5, Q164.3, R328.2
HV204: JP162.6, Q161.3, R322.2
HV205: JP166.1, Q166.3, R332.2
HV206: JP166.2, Q167.3, R334.2
HV207: JP166.3, R330.1, R332.1, R334.1, R336.1
HV208: JP166.5, Q168.3, R336.2
HV209: JP166.6, Q165.3, R330.2
HV210: JP170.1, Q170.3, R340.2
HV211: JP170.2, Q171.3, R342.2
HV212: JP170.3, R338.1, R340.1, R342.1, R344.1
HV213: JP170.5, Q172.3, R344.2
HV214: JP170.6, Q169.3, R338.2
HV215: JP174.1, Q174.3, R348.2
HV216: JP174.2, Q175.3, R350.2
HV217: JP174.3, R346.1, R348.1, R350.1, R352.1
HV218: JP174.5, Q176.3, R352.2
HV219: JP174.6, Q173.3, R346.2
HV220: JP178.1, Q178.3, R356.2
HV221: JP178.2, Q179.3, R358.2
HV222: JP178.3, R354.1, R356.1, R358.1, R360.1
HV223: JP178.5, Q180.3, R360.2
HV224: JP178.6, Q177.3, R354.2
HV225: JP182.1, Q182.3, R364.2
HV226: JP182.2, Q183.3, R366.2
HV227: JP182.3, R362.1, R364.1, R366.1, R368.1
HV228: JP182.5, Q184.3, R368.2
HV229: JP182.6, Q181.3, R362.2
HV230: JP186.1, Q186.3, R372.2
HV231: JP186.2, Q187.3, R374.2
HV232: JP186.3, R370.1, R372.1, R374.1, R376.1
HV233: JP186.5, Q188.3, R376.2
HV234: JP186.6, Q185.3, R370.2
HV235: JP190.1, Q190.3, R380.2
HV236: JP190.2, Q191.3, R382.2
HV237: JP190.3, R378.1, R380.1, R382.1, R384.1
HV238: JP190.5, Q192.3, R384.2
HV239: JP190.6, Q189.3, R378.2
HV240: JP194.1, Q194.3, R388.2
HV241: JP194.2, Q195.3, R390.2
HV242: JP194.3, R386.1, R388.1, R390.1, R392.1
HV243: JP194.5, Q196.3, R392.2
HV244: JP194.6, Q193.3, R386.2
HV245: JP198.1, Q198.3, R396.2
HV246: JP198.2, Q199.3, R398.2
HV247: JP198.3, R394.1, R396.1, R398.1, R400.1
HV248: JP198.5, Q200.3, R400.2
HV249: JP198.6, Q197.3, R394.2
HV250: JP202.1, Q202.3, R404.2
HV251: JP202.2, Q203.3, R406.2
HV252: JP202.3, R402.1, R404.1, R406.1, R408.1
HV253: JP202.5, Q204.3, R408.2
HV254: JP202.6, Q201.3, R402.2
HV255: JP206.1, Q206.3, R412.2
HV256: JP206.2, Q207.3, R414.2
HV257: JP206.3, R410.1, R412.1, R414.1, R416.1
HV258: JP206.5, Q208.3, R416.2
HV259: JP206.6, Q205.3, R410.2
HV260: JP210.1, Q210.3, R420.2
HV261: JP210.2, Q211.3, R422.2
HV262: JP210.3, R418.1, R420.1, R422.1, R424.1
HV263: JP210.5, Q212.3, R424.2
HV264: JP210.6, Q209.3, R418.2
HV265: JP214.1, Q214.3, R428.2
HV266: JP214.2, Q215.3, R430.2
HV267: JP214.3, R426.1, R428.1, R430.1, R432.1
HV268: JP214.5, Q216.3, R432.2
HV269: JP214.6, Q213.3, R426.2
HV270: JP218.1, Q218.3, R436.2
HV271: JP218.2, Q219.3, R438.2
HV272: JP218.3, R434.1, R436.1, R438.1, R440.1
HV273: JP218.5, Q220.3, R440.2
HV274: JP218.6, Q217.3, R434.2
HV275: JP222.1, Q222.3, R444.2
HV276: JP222.2, Q223.3, R446.2
HV277: JP222.3, R442.1, R444.1, R446.1, R448.1
HV278: JP222.5, Q224.3, R448.2
HV279: JP222.6, Q221.3, R442.2
LV: JP1.4, Q1.1, Q2.1, Q3.1, Q4.1, R1.1, R2.1, R3.1, R6.1
LV1: JP1.6, Q1.2, R3.2
LV2: JP1.5, Q3.2, R2.2
LV3: JP1.2, Q4.2, R1.2
LV4: JP1.1, Q2.2, R6.2
LV5: JP5.4, Q5.1, Q6.1, Q7.1, Q8.1, R8.1, R11.1, R13.1, R15.1
LV6: JP5.5, Q7.2, R13.2
LV7: JP5.6, Q6.2, R11.2
LV8: JP5.1, Q5.2, R8.2
LV9: JP5.2, Q8.2, R15.2
LV10: JP9.4, Q9.1, Q10.1, Q11.1, Q12.1, R17.1, R19.1, R21.1, R23.1
LV11: JP9.5, Q11.2, R21.2
LV12: JP9.6, Q10.2, R19.2
LV13: JP9.1, Q9.2, R17.2
LV14: JP9.2, Q12.2, R23.2
LV15: JP13.4, Q13.1, Q14.1, Q15.1, Q16.1, R25.1, R27.1, R29.1, R31.1
LV16: JP13.5, Q15.2, R29.2
LV17: JP13.6, Q14.2, R27.2
LV18: JP13.1, Q13.2, R25.2
LV19: JP13.2, Q16.2, R31.2
LV20: JP17.4, Q17.1, Q18.1, Q19.1, Q20.1, R33.1, R35.1, R37.1, R39.1
LV21: JP17.5, Q19.2, R37.2
LV22: JP17.6, Q18.2, R35.2
LV23: JP17.1, Q17.2, R33.2
LV24: JP17.2, Q20.2, R39.2
LV25: JP21.4, Q21.1, Q22.1, Q23.1, Q24.1, R41.1, R43.1, R45.1, R47.1
LV26: JP21.5, Q23.2, R45.2
LV27: JP21.6, Q22.2, R43.2
LV28: JP21.1, Q21.2, R41.2
LV29: JP21.2, Q24.2, R47.2
LV30: JP25.4, Q25.1, Q26.1, Q27.1, Q28.1, R49.1, R51.1, R53.1, R55.1
LV31: JP25.5, Q27.2, R53.2
LV32: JP25.6, Q26.2, R51.2
LV33: JP25.1, Q25.2, R49.2
LV34: JP25.2, Q28.2, R55.2
LV35: JP29.4, Q29.1, Q30.1, Q31.1, Q32.1, R57.1, R59.1, R61.1, R63.1
LV36: JP29.5, Q31.2, R61.2
LV37: JP29.6, Q30.2, R59.2
LV38: JP29.1, Q29.2, R57.2
LV39: JP29.2, Q32.2, R63.2
LV40: JP33.4, Q33.1, Q34.1, Q35.1, Q36.1, R65.1, R67.1, R69.1, R71.1
LV41: JP33.5, Q35.2, R69.2
LV42: JP33.6, Q34.2, R67.2
LV43: JP33.1, Q33.2, R65.2
LV44: JP33.2, Q36.2, R71.2
LV45: JP37.4, Q37.1, Q38.1, Q39.1, Q40.1, R73.1, R75.1, R77.1, R79.1
LV46: JP37.5, Q39.2, R77.2
LV47: JP37.6, Q38.2, R75.2
LV48: JP37.1, Q37.2, R73.2
LV49: JP37.2, Q40.2, R79.2
LV50: JP41.4, Q41.1, Q42.1, Q43.1, Q44.1, R81.1, R83.1, R85.1, R87.1
LV51: JP41.5, Q43.2, R85.2
LV52: JP41.6, Q42.2, R83.2
LV53: JP41.1, Q41.2, R81.2
LV54: JP41.2, Q44.2, R87.2
LV55: JP45.4, Q45.1, Q46.1, Q47.1, Q48.1, R89.1, R91.1, R93.1, R95.1
LV56: JP45.5, Q47.2, R93.2
LV57: JP45.6, Q46.2, R91.2
LV58: JP45.1, Q45.2, R89.2
LV59: JP45.2, Q48.2, R95.2
LV60: JP49.4, Q49.1, Q50.1, Q51.1, Q52.1, R97.1, R99.1, R101.1, R103.1
LV61: JP49.5, Q51.2, R101.2
LV62: JP49.6, Q50.2, R99.2
LV63: JP49.1, Q49.2, R97.2
LV64: JP49.2, Q52.2, R103.2
LV65: JP53.4, Q53.1, Q54.1, Q55.1, Q56.1, R105.1, R107.1, R109.1, R111.1
LV66: JP53.5, Q55.2, R109.2
LV67: JP53.6, Q54.2, R107.2
LV68: JP53.1, Q53.2, R105.2
LV69: JP53.2, Q56.2, R111.2
LV70: JP57.4, Q57.1, Q58.1, Q59.1, Q60.1, R113.1, R115.1, R117.1, R119.1
LV71: JP57.5, Q59.2, R117.2
LV72: JP57.6, Q58.2, R115.2
LV73: JP57.1, Q57.2, R113.2
LV74: JP57.2, Q60.2, R119.2
LV75: JP61.4, Q61.1, Q62.1, Q63.1, Q64.1, R121.1, R123.1, R125.1, R127.1
LV76: JP61.5, Q63.2, R125.2
LV77: JP61.6, Q62.2, R123.2
LV78: JP61.1, Q61.2, R121.2
LV79: JP61.2, Q64.2, R127.2
LV80: JP65.4, Q65.1, Q66.1, Q67.1, Q68.1, R129.1, R131.1, R133.1, R135.1
LV81: JP65.5, Q67.2, R133.2
LV82: JP65.6, Q66.2, R131.2
LV83: JP65.1, Q65.2, R129.2
LV84: JP65.2, Q68.2, R135.2
LV85: JP69.4, Q69.1, Q70.1, Q71.1, Q72.1, R137.1, R139.1, R141.1, R143.1
LV86: JP69.5, Q71.2, R141.2
LV87: JP69.6, Q70.2, R139.2
LV88: JP69.1, Q69.2, R137.2
LV89: JP69.2, Q72.2, R143.2
LV90: JP73.4, Q73.1, Q74.1, Q75.1, Q76.1, R145.1, R147.1, R149.1, R151.1
LV91: JP73.5, Q75.2, R149.2
LV92: JP73.6, Q74.2, R147.2
LV93: JP73.1, Q73.2, R145.2
LV94: JP73.2, Q76.2, R151.2
LV95: JP77.4, Q77.1, Q78.1, Q79.1, Q80.1, R153.1, R155.1, R157.1, R159.1
LV96: JP77.5, Q79.2, R157.2
LV97: JP77.6, Q78.2, R155.2
LV98: JP77.1, Q77.2, R153.2
LV99: JP77.2, Q80.2, R159.2
LV100: JP81.4, Q81.1, Q82.1, Q83.1, Q84.1, R161.1, R163.1, R165.1, R167.1
LV101: JP81.5, Q83.2, R165.2
LV102: JP81.6, Q82.2, R163.2
LV103: JP81.1, Q81.2, R161.2
LV104: JP81.2, Q84.2, R167.2
LV105: JP85.4, Q85.1, Q86.1, Q87.1, Q88.1, R169.1, R171.1, R173.1, R175.1
LV106: JP85.5, Q87.2, R173.2
LV107: JP85.6, Q86.2, R171.2
LV108: JP85.1, Q85.2, R169.2
LV109: JP85.2, Q88.2, R175.2
LV110: JP89.4, Q89.1, Q90.1, Q91.1, Q92.1, R177.1, R179.1, R181.1, R183.1
LV111: JP89.5, Q91.2, R181.2
LV112: JP89.6, Q90.2, R179.2
LV113: JP89.1, Q89.2, R177.2
LV114: JP89.2, Q92.2, R183.2
LV115: JP93.4, Q93.1, Q94.1, Q95.1, Q96.1, R185.1, R187.1, R189.1, R191.1
LV116: JP93.5, Q95.2, R189.2
LV117: JP93.6, Q94.2, R187.2
LV118: JP93.1, Q93.2, R185.2
LV119: JP93.2, Q96.2, R191.2
LV120: JP97.4, Q97.1, Q98.1, Q99.1, Q100.1, R193.1, R195.1, R197.1, R199.1
LV121: JP97.5, Q99.2, R197.2
LV122: JP97.6, Q98.2, R195.2
LV123: JP97.1, Q97.2, R193.2
LV124: JP97.2, Q100.2, R199.2
LV125: JP101.4, Q101.1, Q102.1, Q103.1, Q104.1, R201.1, R203.1, R205.1, R207.1
LV126: JP101.5, Q103.2, R205.2
LV127: JP101.6, Q102.2, R203.2
LV128: JP101.1, Q101.2, R201.2
LV129: JP101.2, Q104.2, R207.2
LV130: JP105.4, Q105.1, Q106.1, Q107.1, Q108.1, R209.1, R211.1, R213.1, R215.1
LV131: JP105.5, Q107.2, R213.2
LV132: JP105.6, Q106.2, R211.2
LV133: JP105.1, Q105.2, R209.2
LV134: JP105.2, Q108.2, R215.2
LV135: JP109.4, Q109.1, Q110.1, Q111.1, Q112.1, R217.1, R219.1, R221.1, R223.1
LV136: JP109.5, Q111.2, R221.2
LV137: JP109.6, Q110.2, R219.2
LV138: JP109.1, Q109.2, R217.2
LV139: JP109.2, Q112.2, R223.2
LV140: JP113.4, Q113.1, Q114.1, Q115.1, Q116.1, R225.1, R227.1, R229.1, R231.1
LV141: JP113.5, Q115.2, R229.2
LV142: JP113.6, Q114.2, R227.2
LV143: JP113.1, Q113.2, R225.2
LV144: JP113.2, Q116.2, R231.2
LV145: JP117.4, Q117.1, Q118.1, Q119.1, Q120.1, R233.1, R235.1, R237.1, R239.1
LV146: JP117.5, Q119.2, R237.2
LV147: JP117.6, Q118.2, R235.2
LV148: JP117.1, Q117.2, R233.2
LV149: JP117.2, Q120.2, R239.2
LV150: JP121.4, Q121.1, Q122.1, Q123.1, Q124.1, R241.1, R243.1, R245.1, R247.1
LV151: JP121.5, Q123.2, R245.2
LV152: JP121.6, Q122.2, R243.2
LV153: JP121.1, Q121.2, R241.2
LV154: JP121.2, Q124.2, R247.2
LV155: JP125.4, Q125.1, Q126.1, Q127.1, Q128.1, R249.1, R251.1, R253.1, R255.1
LV156: JP125.5, Q127.2, R253.2
LV157: JP125.6, Q126.2, R251.2
LV158: JP125.1, Q125.2, R249.2
LV159: JP125.2, Q128.2, R255.2
LV160: JP129.4, Q129.1, Q130.1, Q131.1, Q132.1, R257.1, R259.1, R261.1, R263.1
LV161: JP129.5, Q131.2, R261.2
LV162: JP129.6, Q130.2, R259.2
LV163: JP129.1, Q129.2, R257.2
LV164: JP129.2, Q132.2, R263.2
LV165: JP133.4, Q133.1, Q134.1, Q135.1, Q136.1, R265.1, R267.1, R269.1, R271.1
LV166: JP133.5, Q135.2, R269.2
LV167: JP133.6, Q134.2, R267.2
LV168: JP133.1, Q133.2, R265.2
LV169: JP133.2, Q136.2, R271.2
LV170: JP137.4, Q137.1, Q138.1, Q139.1, Q140.1, R273.1, R275.1, R277.1, R279.1
LV171: JP137.5, Q139.2, R277.2
LV172: JP137.6, Q138.2, R275.2
LV173: JP137.1, Q137.2, R273.2
LV174: JP137.2, Q140.2, R279.2
LV175: JP141.4, Q141.1, Q142.1, Q143.1, Q144.1, R281.1, R283.1, R285.1, R287.1
LV176: JP141.5, Q143.2, R285.2
LV177: JP141.6, Q142.2, R283.2
LV178: JP141.1, Q141.2, R281.2
LV179: JP141.2, Q144.2, R287.2
LV180: JP145.4, Q145.1, Q146.1, Q147.1, Q148.1, R289.1, R291.1, R293.1, R295.1
LV181: JP145.5, Q147.2, R293.2
LV182: JP145.6, Q146.2, R291.2
LV183: JP145.1, Q145.2, R289.2
LV184: JP145.2, Q148.2, R295.2
LV185: JP149.4, Q149.1, Q150.1, Q151.1, Q152.1, R297.1, R299.1, R301.1, R303.1
LV186: JP149.5, Q151.2, R301.2
LV187: JP149.6, Q150.2, R299.2
LV188: JP149.1, Q149.2, R297.2
LV189: JP149.2, Q152.2, R303.2
LV190: JP153.4, Q153.1, Q154.1, Q155.1, Q156.1, R305.1, R307.1, R309.1, R311.1
LV191: JP153.5, Q155.2, R309.2
LV192: JP153.6, Q154.2, R307.2
LV193: JP153.1, Q153.2, R305.2
LV194: JP153.2, Q156.2, R311.2
LV195: JP157.4, Q157.1, Q158.1, Q159.1, Q160.1, R313.1, R315.1, R317.1, R319.1
LV196: JP157.5, Q159.2, R317.2
LV197: JP157.6, Q158.2, R315.2
LV198: JP157.1, Q157.2, R313.2
LV199: JP157.2, Q160.2, R319.2
LV200: JP161.4, Q161.1, Q162.1, Q163.1, Q164.1, R321.1, R323.1, R325.1, R327.1
LV201: JP161.5, Q163.2, R325.2
LV202: JP161.6, Q162.2, R323.2
LV203: JP161.1, Q161.2, R321.2
LV204: JP161.2, Q164.2, R327.2
LV205: JP165.4, Q165.1, Q166.1, Q167.1, Q168.1, R329.1, R331.1, R333.1, R335.1
LV206: JP165.5, Q167.2, R333.2
LV207: JP165.6, Q166.2, R331.2
LV208: JP165.1, Q165.2, R329.2
LV209: JP165.2, Q168.2, R335.2
LV210: JP169.4, Q169.1, Q170.1, Q171.1, Q172.1, R337.1, R339.1, R341.1, R343.1
LV211: JP169.5, Q171.2, R341.2
LV212: JP169.6, Q170.2, R339.2
LV213: JP169.1, Q169.2, R337.2
LV214: JP169.2, Q172.2, R343.2
LV215: JP173.4, Q173.1, Q174.1, Q175.1, Q176.1, R345.1, R347.1, R349.1, R351.1
LV216: JP173.5, Q175.2, R349.2
LV217: JP173.6, Q174.2, R347.2
LV218: JP173.1, Q173.2, R345.2
LV219: JP173.2, Q176.2, R351.2
LV220: JP177.4, Q177.1, Q178.1, Q179.1, Q180.1, R353.1, R355.1, R357.1, R359.1
LV221: JP177.5, Q179.2, R357.2
LV222: JP177.6, Q178.2, R355.2
LV223: JP177.1, Q177.2, R353.2
LV224: JP177.2, Q180.2, R359.2
LV225: JP181.4, Q181.1, Q182.1, Q183.1, Q184.1, R361.1, R363.1, R365.1, R367.1
LV226: JP181.5, Q183.2, R365.2
LV227: JP181.6, Q182.2, R363.2
LV228: JP181.1, Q181.2, R361.2
LV229: JP181.2, Q184.2, R367.2
LV230: JP185.4, Q185.1, Q186.1, Q187.1, Q188.1, R369.1, R371.1, R373.1, R375.1
LV231: JP185.5, Q187.2, R373.2
LV232: JP185.6, Q186.2, R371.2
LV233: JP185.1, Q185.2, R369.2
LV234: JP185.2, Q188.2, R375.2
LV235: JP189.4, Q189.1, Q190.1, Q191.1, Q192.1, R377.1, R379.1, R381.1, R383.1
LV236: JP189.5, Q191.2, R381.2
LV237: JP189.6, Q190.2, R379.2
LV238: JP189.1, Q189.2, R377.2
LV239: JP189.2, Q192.2, R383.2
LV240: JP193.4, Q193.1, Q194.1, Q195.1, Q196.1, R385.1, R387.1, R389.1, R391.1
LV241: JP193.5, Q195.2, R389.2
LV242: JP193.6, Q194.2, R387.2
LV243: JP193.1, Q193.2, R385.2
LV244: JP193.2, Q196.2, R391.2
LV245: JP197.4, Q197.1, Q198.1, Q199.1, Q200.1, R393.1, R395.1, R397.1, R399.1
LV246: JP197.5, Q199.2, R397.2
LV247: JP197.6, Q198.2, R395.2
LV248: JP197.1, Q197.2, R393.2
LV249: JP197.2, Q200.2, R399.2
LV250: JP201.4, Q201.1, Q202.1, Q203.1, Q204.1, R401.1, R403.1, R405.1, R407.1
LV251: JP201.5, Q203.2, R405.2
LV252: JP201.6, Q202.2, R403.2
LV253: JP201.1, Q201.2, R401.2
LV254: JP201.2, Q204.2, R407.2
LV255: JP205.4, Q205.1, Q206.1, Q207.1, Q208.1, R409.1, R411.1, R413.1, R415.1
LV256: JP205.5, Q207.2, R413.2
LV257: JP205.6, Q206.2, R411.2
LV258: JP205.1, Q205.2, R409.2
LV259: JP205.2, Q208.2, R415.2
LV260: JP209.4, Q209.1, Q210.1, Q211.1, Q212.1, R417.1, R419.1, R421.1, R423.1
LV261: JP209.5, Q211.2, R421.2
LV262: JP209.6, Q210.2, R419.2
LV263: JP209.1, Q209.2, R417.2
LV264: JP209.2, Q212.2, R423.2
LV265: JP213.4, Q213.1, Q214.1, Q215.1, Q216.1, R425.1, R427.1, R429.1, R431.1
LV266: JP213.5, Q215.2, R429.2
LV267: JP213.6, Q214.2, R427.2
LV268: JP213.1, Q213.2, R425.2
LV269: JP213.2, Q216.2, R431.2
LV270: JP217.4, Q217.1, Q218.1, Q219.1, Q220.1, R433.1, R435.1, R437.1, R439.1
LV271: JP217.5, Q219.2, R437.2
LV272: JP217.6, Q218.2, R435.2
LV273: JP217.1, Q217.2, R433.2
LV274: JP217.2, Q220.2, R439.2
LV275: JP221.4, Q221.1, Q222.1, Q223.1, Q224.1, R441.1, R443.1, R445.1, R447.1
LV276: JP221.5, Q223.2, R445.2
LV277: JP221.6, Q222.2, R443.2
LV278: JP221.1, Q221.2, R441.2
LV279: JP221.2, Q224.2, R447.2
