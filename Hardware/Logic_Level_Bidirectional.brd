# Repository sparkfun/Logic_Level_Bidirectional

File README.md:

Logic Level Converter Bidirectional
=========================

[*Logic Level Converter Bi-Directional (BOB-12009)*](https://www.sparkfun.com/products/12009)

This is a bidirectional logic level converter that allows you to communicate between 3.3V and 5V devices, or 2.8V and 1.8V devices.

Repository Contents
-------------------
* **/Hardware** - All Eagle design files (.brd, .sch, .STL)
* **/Production** - Test bed files and production panel files

Documentation
--------------
* **[Hookup Guide](https://learn.sparkfun.com/tutorials/bi-directional-logic-level-converter-hookup-guide)** - Basic hookup guide
* **[SparkFun Fritzing repo](https://github.com/sparkfun/Fritzing_Parts)** - Fritzing diagrams for SparkFun products.

License Information
-------------------
The hardware is released under [Creative Commons Share-alike 3.0](http://creativecommons.org/licenses/by-sa/3.0/).

## EAGLE design Hardware/Logic_Level_Bidirectional.brd

Parts:
JP1, JP2: M06SIP; 1X06
JP3, JP4: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
LOGO1: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
LOGO2: OSHW-LOGOS; OSHW-LOGO-S
Q1, Q2, Q3, Q4: BSS138; SOT23-3
R1, R2, R3, R4, R5, R6, R7, R10: 10K; 0603-RES

Connections:
GND: JP1.3, JP2.4
HV: JP2.3, R4.1, R5.1, R7.1, R10.1
HV1: JP2.1, Q1.3 (D), R4.2
HV2: JP2.2, Q3.3 (D), R10.2
HV3: JP2.5, Q4.3 (D), R5.2
HV4: JP2.6, Q2.3 (D), R7.2
LV: JP1.4, Q1.1 (G), Q2.1 (G), Q3.1 (G), Q4.1 (G), R1.1, R2.1, R3.1, R6.1
LV1: JP1.6, Q1.2 (S), R3.2
LV2: JP1.5, Q3.2 (S), R2.2
LV3: JP1.2, Q4.2 (S), R1.2
LV4: JP1.1, Q2.2 (S), R6.2

Notes on the sheet:
High Voltage
Low Voltage
V01
Patrick Alberts

Board: 2 copper layers, 15.2 x 12.7 mm, 18 parts (4 on the bottom side), 11 nets.

Notices in the files:
parts and their libraries:
SparkFun-Aesthetics: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
